# Repository Elecrow-RD/nRF52840

File README.md:

### File introduction: 

#### firmware: here is the LR1110, LR1121, SX1262 & LLCC68 firmware file; 

#### lora_development_board: here is supporting the development of different modules of the board schematic diagrams, the user can download and use their own; 

#### sendATcommands_new: here is the lora send commands code program;

## EAGLE design lora_development_board/nRFLRxxxx/Transceiver Module Dev Board（with MCU）_V1.0/Transceiver Module Dev Board（with MCU）_V1.0.brd

File lora_development_board/readme.md:

### Corresponding modules use corresponding development boards: 

##### LR1262&LRCC68: the corresponding development board is Transceiver Module Dev Board (without MCU)_V0.1_SCH; 

##### nRFLRxxxx: the corresponding development board is Transceiver Module Dev Board (with Transceiver Module Dev Board (with MCU)_V0.1.

Parts:
ANT1, ANT2: ANT2.4G_BLE; 2.4G_BLE
ANT3, ANT4, ANT5: C5137195; MYSELF_IPEX1
C1, C3: 10uF/0603; C0603
C2, C6, C9, C12, C23, C25, C33: 100nF; C0402
C4, C10: 47pF; C0402
C5, C60: 2.4nH; DISCRETE-NEW_C0402
C7, C8: 22uF; 0603
C11, C13, C17, C55, C63, C64: NC; DISCRETE-NEW_C0402
C14, C16: DNP; C0402
C15, C61: 12pF; DISCRETE-NEW_C0402
C21, C22: 10uF; 0402
C53: 100pF; DISCRETE-NEW_C0402
D1, D10: DSS34; D_SOD123FL
FB1, FB2: 120R/2A/BLM18PG121SN1D; L0603
J1, J2, J4, J6, J7, J9, J10, J11: CONNECTOR_TWIG-4P-2.0-SMD-FEMALE-REINFORCE90D; CONNECTOR_4P-SMD-2.0-90D
J3: USB_TYPE-C_16PIN3.0USB; KEVIN_3.0TYPEC-SMD
J5: PH2.0WT-2PIN
J8: 2.0MM-4P
K1, K2: BUTTON; 157SW
L2, L12: 4.7nH; XADOW-GPS-V2_DISCRETE-NEW_L0402
L3, L14: 3.6nH; XADOW-GPS-V2_DISCRETE-NEW_L0402
L4: 4.7uH/1.6A; A9G_DISCRETE_L0805
L5: 0R; L0402
L7: 27nH; L0402
LED1: RED; DISCRETE_LED-0603
LED2: BLUE; DISCRETE_LED-0603
P1, P2, P3, P4, P5, P6, P7, P8, P9, P10, P11, P12, P13, P14, P15, P16, P17, P18, P19, P20, P21, P22, P23: TEST_PAD; TEST_PAD-1.5MM
Q1: BSS138LT1; SOT-323
Q3: PMOS-3401-4A; SOT-23
Q4: CJ3407A; SOT-323
R1: 1K; 0402
R2, R16: 0R; DISCRETE-NEW_R0402
R3, R22: 4.7K; 0402
R4, R6: 4.7K; DISCRETE_R0603
R5: 2K; 0402
R7, R8, R9, R19, R20, R21: 10K; 0402
R10: 1k; R0402
R11, R12: 0R; R0402
R13, R27: 100k; R0402
R17: 45.3K; 0402
R18, R23: 22R; 0402
R24, R25: 5.1K; 0402
U1: RY3420; CROWBOT_-V1.0-20220525_A_XBJ_SOT23-5
U3: nRFLRXXXX_MODULE_A_SMD80nRFLRXXXX_MO_SMT80; LR11XX_MO_A_SMD80
U4: W25Q64JVXGIQ; XSON-EP(4×4)
U6: DFN8_4054A; DFN8_SOP23-5
Y2: 32.768K; NORDIC_NRF_XTAL_3215_N

Connections:
3V3: C8.2, C9.1, FB1.2, FB2.2, J1.3, J2.3, J4.3, J6.3, J7.3, J8.P$1, J9.3, J10.3, J11.3, L4.2, P3.P$1, P9.P$1, P15.P$1, P19.P$1, Q4.2 (S), R3.2, R4.2, R6.2, R8.2, R9.2, R13.2, R17.2, R20.2, R21.2, R22.2, U4.8 (VCC)
BAT+: C22.2, C25.1, D10.+, J5.P$1, Q3.3 (D), U6.3 (BAT)
D+: J3.A6 (DP1), J3.B6 (DP2), R23.2
D-: J3.A7 (DN1), J3.B7 (DN2), R18.2
DN: R18.1, U3.40 (DN)
DP: R23.1, U3.41 (DP)
GND: ANT3.P$2, ANT3.P$3, ANT4.P$2, ANT4.P$3, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.1, C15.2, C16.1, C17.2, C21.1, C22.1, C23.2, C25.2, C33.1, C55.2, C60.2, C61.2, C63.1, C64.2, J1.4, J1.SS1, J1.SS2, J2.4, J2.SS1, J2.SS2, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.P$6, J3.P$7, J3.P$8, J3.P$9, J4.4, J4.SS1, J4.SS2, J5.P$2, J5.P$3, J5.P$4, J6.4, J6.SS1, J6.SS2, J7.4, J7.SS1, J7.SS2, J8.P$2, J9.4, J9.SS1, J9.SS2, J10.4, J10.SS1, J10.SS2, J11.4, J11.SS1, J11.SS2, K1.1, K2.1, LED1.-, P2.P$1, P8.P$1, P14.P$1, P18.P$1, Q1.2 (S), R5.1, R7.1, R19.1, R24.1, R25.2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
LNA_CTL_P0.19: R10.2, U3.63 (P0.19)
LR_DIO7: R12.2, U3.24 (LR_DIO7)
LR_DIO8: P1.P$1, U3.23 (LR_32K_OUT)
LR_DIO9: R11.2, U3.11 (LR_DIO9)
unnamed: LED2.+, R22.1
unnamed: L12.1, U3.54 (ANT_BLE)
unnamed: C5.1, L2.2, L3.1
unnamed: ANT2.P$1, C13.1, L3.2
unnamed: L2.1, U3.65 (ANT_WIFI)
unnamed: J3.B5 (CC2), R24.2
unnamed: C55.1, R2.1, U3.67 (ANT_GNSS)
unnamed: R16.1, U3.72 (ANT_LORA)
unnamed: LED1.+, R3.1
unnamed: Q3.1 (G), R1.1, R7.2
unnamed: J3.A5 (CC1), R25.1
unnamed: L4.1, U1.3 (SW)
unnamed: C14.2, L5.1, R16.2
unnamed: ANT4.P$1, C16.2, L5.2
unnamed: Q1.3 (D), Q4.1 (G), R13.1
unnamed: Q1.1 (G), R10.1, R27.2
unnamed: R17.1, R19.2, U1.5 (FB)
unnamed: R5.2, U6.5 (PROG)
unnamed: C33.2, L7.1, Q4.3 (D)
unnamed: C17.1, C53.2, R2.2
unnamed: C60.1, L12.2, L14.1
unnamed: ANT1.P$1, C11.1, L14.2
P0.00/XL1: C15.1, U3.29 (P0.00), Y2.2
P0.01/XL2: C61.1, U3.30 (P0.01), Y2.1
P0.02/AIN0: U3.12 (P0.02)
P0.03/AIN1: U3.13 (P0.03)
P0.04/AIN2: J7.1, P5.P$1, U3.31 (P0.04)
P0.05/AIN3: J7.2, P4.P$1, U3.17 (P0.05)
P0.06/SDA_1: J11.2, P12.P$1, R8.1, U3.32 (P0.06)
P0.07/SCL_1: J11.1, P13.P$1, R9.1, U3.19 (P0.07)
P0.08/D2: J4.2, P23.P$1, U3.33 (P0.08)
P0.09/NFC1: ANT5.P$1, C63.2, U3.56 (P0.09)
P0.10/NFC2: ANT5.P$2, ANT5.P$3, C64.1, U3.55 (P0.10)
P0.11: R12.1, U3.25 (P0.11)
P0.12/D2: J4.1, P22.P$1, U3.35 (P0.12)
P0.13/SDA_0: J6.2, J9.2, P10.P$1, R20.1, U3.39 (P0.13)
P0.14/SCL_0: J6.1, J9.1, P11.P$1, R21.1, U3.38 (P0.14)
P0.15: U3.42 (P0.15)
P0.16: U3.26 (P0.16)
P0.17: U3.43 (P0.17)
P0.18/NRESET: K1.2, R4.1, U3.36 (P0.18)
P0.20: U3.45 (P0.20)
P0.21: U3.49 (P0.21)
P0.22/UART_RXD: J10.1, P17.P$1, U3.46 (P0.22)
P0.23/QSPI_IO3: U3.59 (P0.23), U4.7 (/HOLD/RESET(IO3))
P0.24/UART_TXD: J10.2, P16.P$1, U3.47 (P0.24)
P0.25: U3.52 (P0.25)
P0.26/D1: J2.1, P21.P$1, U3.18 (P0.26)
P0.27/D1: J2.2, P20.P$1, U3.16 (P0.27)
P0.28/AIN4: J1.1, P7.P$1, U3.14 (P0.28)
P0.29/AIN5: J1.2, P6.P$1, U3.9 (P0.29)
P0.30/AIN6: U3.15 (P0.30)
P0.31/AIN7: U3.10 (P0.31)
P1.00/USER_KEY: K2.2, R6.1, U3.48 (P1.00)
P1.01/QSPI_IO2: U3.60 (P1.01), U4.3 (/WP(IO2))
P1.02/QSPI_IO0: U3.58 (P1.02), U4.5 (DI(IO0))
P1.03/QSPI_IO1: U3.61 (P1.03), U4.2 (DO(IO1))
P1.04/QSPI_SCK: U3.57 (P1.04), U4.6 (CLK)
P1.05/QSPI_CS: U3.62 (P1.05), U4.1 (/CS)
P1.08: R11.1, U3.20 (P1.08)
P1.09/LED: LED2.-, U3.34 (P1.09)
RF_GPS: ANT3.P$1, C53.1, L7.2
SWDCLK: J8.P$4, U3.51 (SWDCLK)
SWDIO: J8.P$3, U3.50 (SWDIO)
VBUS: C21.2, C23.1, D1.+, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R1.2, U3.37 (VBUS), U6.4 (VCC)
VDD_NRF: C1.1, C2.1, C10.1, FB1.1, U3.27 (VDD_NRF_27), U3.28 (VDD_NRF_28)
VDD_RADIO: C3.1, C4.1, C12.1, FB2.1, U3.21 (VDD_LR_21), U3.22 (VDD_LR_22)
VIN: C6.1, C7.2, D1.-, D10.-, Q3.2 (S), U1.1 (EN), U1.4 (VIN)

Notes on the sheet:
系统3.3V电源
UART Interface
MCU NRF52840
USB type-c座子
电池及控制电路
POWER LED
HM3416H更换为RY3420
BAT
FLASH
BLE_ANT
RESET
USER
WIFI_ANT
SWD
GPS_ANT
LORA_ANT
NFC

Board: 2 copper layers, 48.1 x 70.0 mm, 114 parts (22 on the bottom side), 69 nets.

## EAGLE design lora_development_board/LR1262&LRCC68/Transceiver Module Dev Board（without MCU）_V0.1/Transceiver Module Dev Board（without MCU）_V0.1.brd

Parts:
C1, C2, C16: 1uF; C0603
C3: 10uF; C0603
C4: 100nF; C0603
C6, C9, C13, C23, C25: 100nF; C0402
C7, C8: 22uF; 0603
C10, C11: NC; C0402
C12: 10uF/0603; C0603
C14: 47pF; C0402
C21, C22: 10uF; 0402
D1, D10: DSS34; D_SOD123FL
D15: LXES15AAA1-153; 0402-ESD
FB1: 0R/800mA; L0603
FB2: 120R/2A/BLM18PG121SN1D; L0603
J1: TYPEC-3.0-16P-SMD; USB-3.0TYPEC-SMD
J2: PH2.0WT-2PIN
J3, J4, J5, J6, J7, J8, J9, J10: CONNECTOR_TWIG-4P-2.0-SMD-FEMALE-REINFORCE90D; CONNECTOR_4P-SMD-2.0-90D
K1, K2: BUTTON; 157SW
L4: 4.7uH/1.6A; A9G_DISCRETE_L0805
LED1: RED; DISCRETE_LED-0603
LED2: BLUE; DISCRETE_LED-0603
LR_ANT: C5137195; MYSELF_IPEX1
P1, P2, P3, P4: TEST_PADPAD-1.5MM; TEST_PAD-1.5MM
P5, P6, P7, P8, P9, P10, P11, P12, P13, P14, P15, P16, P17, P18, P19, P20, P21, P22, P23, P24, P25, P26: TEST_PAD; TEST_PAD-1.5MM
Q3: PMOS-3401-4A; SOT-23
R1, R2: 5.1K; R0603-SP
R3: 2K; 0402
R4: 1K; 0402
R5, R9, R22: 10K; R0603-SP
R6, R7, R8, R10: 0R; R0603-SP
R11, R16, R17, R18, R20, R21: 10K; 0402
R12, R13: 4.7K; 0402
R14: 0R; R0402
R19: 45.3K; 0402
U1: CH340K; ESOP-10-EP-150MIL
U2: ESP32-S3-WROOM-1; ESP32-S3-WROOM-1-SMD41
U3: RY3420; CROWBOT_-V1.0-20220525_A_XBJ_SOT23-5
U4: LR1262_LRCC68_MD_1010MM; LR1262_LRCC68_MD_10*10MM
U6: DFN8_4054A; DFN8_SOP23-5
U8: UMH3NTN; SOP65P210X100-6N

Connections:
3V3: C1.2, C2.2, C3.2, C4.2, C8.2, C9.1, FB1.1, FB2.1, J3.3, J4.3, J5.3, J6.3, J7.3, J8.3, J9.3, J10.3, L4.2, P6.P$1, P12.P$1, P15.P$1, P19.P$1, R12.2, R13.2, R16.2, R17.2, R18.2, R19.2, R21.2, U1.7 (VCC), U1.10 (V3)
+VBUS: C21.2, C23.1, D1.+, J1.A4, J1.A9, J1.B4, J1.B9, P1.P$1, R4.2, U6.4 (VCC)
ANT: C10.1, R14.1, U4.P$11 (ANT_LR_11)
BAT+: C22.2, C25.1, D10.+, J2.P$1, Q3.3 (D), U6.3 (BAT)
CH_EN: C16.2, K2.2, R22.2, U2.3 (EN), U8.6 (C1)
DIO2: U4.P$7 (LR_DIO2_7), U4.P$15 (TX/RX_EN_15)
DTR: R5.2, U1.4 (DTR#), U8.4 (E2)
ESP_3V3: FB1.2, R22.1, U2.2 (3V3)
ESP_RXD0: R10.1, U2.36 (RXD0)
ESP_TXD0: R8.1, U2.37 (TXD0)
GND: C1.1, C2.1, C3.1, C4.1, C6.2, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C16.1, C21.1, C22.1, C23.2, C25.2, D15.1, J1.A1, J1.A12, J1.B1, J1.B12, J1.P$1, J1.P$2, J1.P$3, J1.P$4, J2.P$2, J2.P$3, J2.P$4, J3.4, J3.SS1, J3.SS2, J4.4, J4.SS1, J4.SS2, J5.4, J5.SS1, J5.SS2, J6.4, J6.SS1, J6.SS2, J7.4, J7.SS1, J7.SS2, J8.4, J8.SS1, J8.SS2, J9.4, J9.SS1, J9.SS2, J10.4, J10.SS1, J10.SS2, K1.1, K2.1, LED1.-, LR_ANT.P$2, LR_ANT.P$3, P4.P$1, P5.P$1, P11.P$1, P14.P$1, P18.P$1, R1.2, R2.1, R3.1, R11.1, R20.1, U1.3 (GND), U1.EP, U2.1 (GND), U2.40 (GND), U2.41 (GND), U2.42 (GND), U2.43 (GND), U2.44 (GND), U2.45 (GND), U2.46 (GND), U2.47 (GND)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
IO0_BOOT: K1.2, U2.27 (IO0), U8.3 (C2)
IO3_R6: U2.15 (IO3), U4.P$16 (VDD_SW_16)
IO4_LR_NRESET: U2.4 (IO4), U4.P$10 (LR_NRESET_10)
IO5_LR_BUSY: U2.5 (IO5), U4.P$9 (LR_BUSY_9)
IO6_LR_DIO1: U2.6 (IO6), U4.P$8 (LR_DIO1_8)
IO7_NSS: U2.7 (IO7), U4.P$2 (LR_NSS_2)
IO8_SPI_SCK: U2.12 (IO8), U4.P$3 (LR_SCK_3)
IO9_G_A2: J4.2, P7.P$1, U2.17 (IO9)
IO10_G_A2: J4.1, P8.P$1, U2.18 (IO10)
IO11_G_D1: J5.2, P20.P$1, U2.19 (IO11)
IO12_G_D1: J5.1, P21.P$1, U2.20 (IO12)
IO13_G_D2: J6.2, P22.P$1, U2.21 (IO13)
IO14_G_D2: J6.1, P23.P$1, U2.22 (IO14)
IO15_G_A1: J3.2, P9.P$1, U2.8 (IO15)
IO16_G_A1: J3.1, P10.P$1, U2.9 (IO16)
IO17_SPI_MISO: U2.10 (IO17), U4.P$5 (LR_MISO_5)
IO18_SPI_MOSI: U2.11 (IO18), U4.P$4 (LR_MOSI_4)
IO19_UART_RX: J7.1, P17.P$1, U2.13 (IO19)
IO20_UART_TX: J7.2, P16.P$1, U2.14 (IO20)
IO21_LED: LED2.-, U2.23 (IO21)
IO38_SDA_1: J10.2, P25.P$1, R17.1, U2.31 (IO38)
IO39_SCL_1: J10.1, P26.P$1, R18.1, U2.32 (IO39)
IO40_SDA_0: J8.2, J9.2, P13.P$1, R16.1, U2.33 (IO40)
IO41_SCL_0: J8.1, J9.1, P24.P$1, R21.1, U2.34 (IO41)
LR_3V3: C12.1, C13.1, C14.1, FB2.2, U4.P$1 (VDD_3V3_1)
unnamed: J1.B5, R1.1
unnamed: J1.A5, R2.2
unnamed: Q3.1 (G), R4.1, R11.2
unnamed: R6.1, U1.1 (UD+)
unnamed: R7.1, U1.2 (UD-)
unnamed: R5.1, U8.2 (B1)
unnamed: R9.1, U8.5 (B2)
unnamed: R8.2, U1.9 (RXD)
unnamed: R10.2, U1.8 (TXD)
unnamed: LED2.+, R12.1
unnamed: L4.1, U3.3 (SW)
unnamed: LED1.+, R13.1
unnamed: C11.1, D15.2, LR_ANT.P$1, R14.2
unnamed: R19.1, R20.2, U3.5 (FB)
unnamed: R3.2, U6.5 (PROG)
RTS: R9.2, U1.6 (RTS#), U8.1 (E1)
USB_D+: J1.A6, J1.B6, P2.P$1, R6.2
USB_D-: J1.A7, J1.B7, P3.P$1, R7.2
VIN: C6.1, C7.2, D1.-, D10.-, Q3.2 (S), U3.1 (EN), U3.4 (VIN)

Notes on the sheet:
ESP32-S3-N8R8
电池及控制电路
BAT
BOOT
RST
UART Interface
GPIO Analog
GPIO Digit
I2C Interface
LR1262/LRCC68_Module
系统3V3
USB转串口_CH340K
USB_Type C
LED
